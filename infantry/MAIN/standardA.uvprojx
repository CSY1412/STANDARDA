# Keil uVision project standardA.uvprojx, settings and files
target RM2019_STANDARD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STANDARD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE;..\TASK;..\SYSTEM\usart;..\BSP;..\CMSIS\inc;..\SYSTEM;..\MAIN;..\RmLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./: main.c app.c
  group TASK
    ../TASK/: CONFIG_PARAM_task.c STAT_JUDGE_task.c DETECTION_task.c CONCLUDE_task.c REFERENCE_task.c SHOOT_task.c GIMBAL_task.c CHASIS_task.c AUX_task.c IO_task.c
  group BSP
    ../BSP/: beep.c can.c flash.c fricmotor.c key.c led.c pid.c timer3.c usart1.c usart2.c usart3.c usart4.c usart5.c usart6.c user_lib.c
  group RmLib
    ../RmLib/: RMLib.lib ramp.h pid_regulator.h LostCounter.h fifo.h common.h
  group CMSIS
    ../CMSIS/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
